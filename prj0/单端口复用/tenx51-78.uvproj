# Keil uVision project tenx51-78.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5278B tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000) XRAM(0xFF00-0xFFFF)
  output: tenx51-78 +hex
  c flags: Optimize=9 SizeSpeed=1
  group New Group
    ./: keys.c display.c init.c main.c isr.c
